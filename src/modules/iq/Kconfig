## src/modules/spinner/Kconfig
```kconfig
menuconfig MODULES_SPINNER
	bool "spinner"
	default n
	---help---
		Enable support for spinner
```
